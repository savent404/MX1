# Keil uVision project MX_AudioPlayer.uvprojx, settings and files
target MX_AudioPlayer (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MX_AudioPlayer
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;                   ../Drivers/STM32F1xx_HAL_Driver/Inc;                   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                   ../Middlewares/Third_Party/FatFs/src/drivers;                   ../Middlewares/Third_Party/FatFs/src;                   ../Drivers/CMSIS/Include;                   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                   ../../AudioPlayer;                   ..\..\AudioFormat;                   ..\..\TX_CFG;                   ..\..\Lis3D;                 ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                 ../Middlewares/Third_Party/FreeRTOS/Source/include;                 ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f1xx_it.c fatfs.c main.c stm32f1xx_hal_msp.c bsp_driver_sd.c adc.c tim.c gpio.c dma.c sdio.c dac.c spi.c STM32_F1xx_HALLib.lib freertos.c stm32f1xx_hal_timebase_TIM.c Task.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dac.c stm32f1xx_hal_flash.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_adc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/AudioPlayer
    ../../AudioPlayer/: AP.c AP_OS.c
  group Application/CFG
    ../../TX_CFG/: tx_cfg.c
  group Application/Lis3D
    ../../Lis3D/: Lis3D.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c event_groups.c croutine.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/LED
    ../Src/: LED.c
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0
